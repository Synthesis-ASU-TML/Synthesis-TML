//
//	jit.ys.pixelweight.c
//						05.26.03	by Yoichiro Serita

#include "jit.common.h"

typedef struct _jit_ys_pixelweight 
{
	t_object				ob;
	
	float param[6];		// parameter
	long paramcount;
	
} t_jit_ys_pixelweight;


void *_jit_ys_pixelweight_class;

t_jit_ys_pixelweight *jit_ys_pixelweight_new(void);
void jit_ys_pixelweight_free(t_jit_ys_pixelweight *x);
t_jit_err jit_ys_pixelweight_matrix_calc(t_jit_ys_pixelweight *x, void *inputs, void *outputs);
t_jit_err jit_ys_pixelweight_calculate_ndim(t_jit_ys_pixelweight *x, long dimcount, long *dim, long planecount, 
	t_jit_matrix_info *in_minfo, char *bip, t_jit_matrix_info *out_minfo, char *bop);

t_jit_err jit_ys_pixelweight_init(void);


void Evaluate(char *bip, char *bop, long dimstride, long width, long height, float param[]){
	long i, j;
	long val;
        
   
    	// apply equation
    	for(j=0; j<height; j++){
    		uchar *ip = bip + j*dimstride;	// dimstride[1] == width (bytes)
		uchar  *op = bop  + j*dimstride;
	
		for( i=0; i<width; i++){
			
			int a1 = (i != width-1) ? ip[(i+1)*2]  : 0;
			int a2 = (i != 0) ? ip[(i-1)*2]  : 0;
			int a3 = (j != height-1) ? ip[i*2+dimstride]  : 0;
			int a4 = (j != 0) ? ip[i*2-dimstride] : 0;
					
			val =  param[0]*ip[i*2] + param[1]*ip[i*2+1] + param[2]*a1 +
					param[3]*a2 + param[4]*a3 + param[5]*a4;
			
	    		if(val < 0) val = 0;
	    		else if(val > 255) val = 255;
	    
	    		op[i*2] = val;
			op[i*2+1] = ip[i*2];
		}
    	}
}


t_jit_err jit_ys_pixelweight_init(void) 
{
	long attrflags=0;
	t_jit_object *attr;
	t_jit_object *mop;
	
	_jit_ys_pixelweight_class = jit_class_new("jit_ys_pixelweight",(method)jit_ys_pixelweight_new,(method)jit_ys_pixelweight_free,
		sizeof(t_jit_ys_pixelweight),A_CANT,0L); //A_CANT = untyped

	// add mop
	mop = jit_object_new(_jit_sym_jit_mop,1,1);	// 1 matrix input / 1 matrix output
	jit_class_addadornment(_jit_ys_pixelweight_class,mop);
	
	// add methods
	jit_class_addmethod(_jit_ys_pixelweight_class, (method)jit_ys_pixelweight_matrix_calc, "matrix_calc", A_CANT, 0L);


	// add attributes (long array)
	attrflags = JIT_ATTR_GET_DEFER_LOW | JIT_ATTR_SET_USURP_LOW;	
	attr = jit_object_new(_jit_sym_jit_attr_offset_array,"param",_jit_sym_float32,
		JIT_MATRIX_MAX_PLANECOUNT, attrflags,(method)0L,(method)0L,
		calcoffset(t_jit_ys_pixelweight,paramcount),calcoffset(t_jit_ys_pixelweight,param));
	jit_class_addattr(_jit_ys_pixelweight_class,attr);
	
		
	jit_class_register(_jit_ys_pixelweight_class);

	return JIT_ERR_NONE;
}


t_jit_err jit_ys_pixelweight_matrix_calc(t_jit_ys_pixelweight *x, void *inputs, void *outputs)
{
	t_jit_err err=JIT_ERR_NONE;
	long in_savelock,out_savelock;
	t_jit_matrix_info in_minfo,out_minfo;
	char *in_bp,*out_bp;
	long i,dimcount,planecount,dim[JIT_MATRIX_MAX_DIMCOUNT];
	void *in_matrix,*out_matrix;
	
	in_matrix 	= jit_object_method(inputs,_jit_sym_getindex,0);			// 1st matrix
	out_matrix 	= jit_object_method(outputs,_jit_sym_getindex,0);		// 1st matrix

	if (x&&in_matrix&&out_matrix) {
		in_savelock = (long) jit_object_method(in_matrix,_jit_sym_lock,1); 
		out_savelock = (long) jit_object_method(out_matrix,_jit_sym_lock,1);
		
		jit_object_method(in_matrix,_jit_sym_getinfo,&in_minfo);
		jit_object_method(out_matrix,_jit_sym_getinfo,&out_minfo);
		
		jit_object_method(in_matrix,_jit_sym_getdata,&in_bp);
		jit_object_method(out_matrix,_jit_sym_getdata,&out_bp);
		
		if (!in_bp) { err=JIT_ERR_INVALID_INPUT; goto out;}
		if (!out_bp) { err=JIT_ERR_INVALID_OUTPUT; goto out;}
		
		//compatible types?
		if ((in_minfo.type!=out_minfo.type)) { 
			err=JIT_ERR_MISMATCH_TYPE; 
			goto out;
		}		

		//compatible planes?
		if (in_minfo.planecount!=out_minfo.planecount) {
			err=JIT_ERR_MISMATCH_PLANE; 
			goto out;
		}

		//get dimensions/planecount
		dimcount   = out_minfo.dimcount;
		planecount = out_minfo.planecount;			
		for (i=0;i<dimcount;i++) {
			dim[i] = MIN(in_minfo.dim[i],out_minfo.dim[i]);
		}		

		//calculate
		jit_ys_pixelweight_calculate_ndim(x, dimcount, dim, planecount, &in_minfo, in_bp, &out_minfo, out_bp);
		
	} else {
		return JIT_ERR_INVALID_PTR;
	}
	
out:
	jit_object_method(out_matrix,_jit_sym_lock,out_savelock);
	jit_object_method(in_matrix,_jit_sym_lock,in_savelock);
	return err;
}

//recursive function to handle higher dimension matrices, by processing 2D sections at a time 
t_jit_err jit_ys_pixelweight_calculate_ndim(t_jit_ys_pixelweight *x, long dimcount, long *dim, long planecount, 
	t_jit_matrix_info *in_minfo, char *bip, t_jit_matrix_info *out_minfo, char *bop)
{
	long i, j, width, height;
	uchar *ip, *op;
		
	if (dimcount<1) return 0; //safety

	switch(dimcount) {
	case 1:
		dim[1] = 1;
	case 2:
		width = dim[0];
		height = dim[1];
		
		if (in_minfo->type==_jit_sym_char) {
			switch (planecount) {
			case 1:	// Grayscale
				/*for (i=0; i<height; i++){
					ip = bip + i*in_minfo->dimstride[1];		// dimstride[1] == width (bytes)
					op = bop  + i*out_minfo->dimstride[1];
					
					for(j=0; j<width; j++){
						op[j] = ip[j];	// (i, j)
					}
				}
				*/

				post("warning: plane count .. 1");
				return 1;
				break;
				
			case 2:
				Evaluate(bip, bop, in_minfo->dimstride[1], width, height, x->param);
				return 1;
				break;
				
			case 4:	// 4 plane (ARGB)
				/*
				for (i=0; i<height; i++){
					long *ipp = bip + i*in_minfo->dimstride[1];	// dimstride[1] == width*4 (bytes)
					long *opp = bop  + i*out_minfo->dimstride[1];
					
					for(j=0; j<width; j++, ipp++, opp++){
						ip = ipp;
						op = opp;
						
						op[0] = ip[0];	// alpha
						
						switch(1){
							case 1:
								op[1] = ip[2];	// R <-G
								op[2] = ip[3];	// G <- B
								op[3] = ip[1];	// B <- R
								break;
							case 2:
								op[1] = ip[3];	// R <- B
								op[2] = ip[1];	// G <- R
								op[3] = ip[2];	// B <- G
								break;
							default:
								op[1] = ip[1];	// R <- R
								op[2] = ip[2];	// G <- G
								op[3] = ip[3];	// B <- B
								break;
						}		
					}
				}
				*/
				post("warning: plane count .. 4");
				return 1;
				
				break;
			default:/*
				for (i=0; i<height; i++){
					ip = bip + i*in_minfo->dimstride[1];
					op = bop  + i*out_minfo->dimstride[1];					
				}*/
				post("warning: plane count .. default");
				return 1;
				break;
			}
		}
		break;
		
	default:
		break;
		//for(i=0; i<dim[dimcount-1]; i++) {
		//	ip = bip + i*in_minfo->dimstride[dimcount-1];
	//		op = bop + i*out_minfo->dimstride[dimcount-1];
	//	}
	}
	return 0;
}

t_jit_ys_pixelweight *jit_ys_pixelweight_new(void)
{
	t_jit_ys_pixelweight *x;
	long i;
		
	if (x=(t_jit_ys_pixelweight *)jit_object_alloc(_jit_ys_pixelweight_class)) {
		// attributes initialization	
		x->param[0] = 1.0f;
		for(i=1; i<6; i++) x->param[i] = 0.0f;
	} else {
		x = NULL;
	}	
	return x;
}

void jit_ys_pixelweight_free(t_jit_ys_pixelweight *x)
{
	//nada
}
